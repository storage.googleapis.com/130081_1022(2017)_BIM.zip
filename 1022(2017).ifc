Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-14T08:25:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 14 08:25:33 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{756BE0F1-8D5B-436B-B806-7369AE73F604}\ifc * Database version: 5507 * Database creation date: Thu Jun 14 08:25:31 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 14 08:25:31 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 14 08:25:31 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 1022 Kitchen faucet, 1022(2017):1022 Kitchen faucet:293198
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 251 mm; FaucetNominalHeight: 162 mm; FaucetNominalWidth: 54 mm; HandShowerNominalDepth: 78 mm; HandShowerNominalHeight: 361.5 mm; HandShowerNominalWidth: 43 mm; InletConnectionSize: 10 mm
Type - General - Author: Convergo AB; BIMObjectName: 1022(2017); ConvergoRefNr: 0087-1806-0033-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Kitchen faucet with side brush; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 05/06/2018
Type - Green Building Properties - EAN Number: 6414150078835; LVI Number: 6219141; Noise Class: I (ISO 3822); NRF Number: 4200409; RSK Number: 8310565; STF Certificate: VTT-RTH-00090-17; VVS Number: 705899304
Type - Identity Data - Class: Single lever; Group: Kitchen faucets; Manufacturer: Oras; Market: INT;DNK;EST;LVA;LTU;NOR;POL;RUS;SWE;UKR;FIN; Model: 1022 Kitchen faucet; Name_en: 1022 Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1022; Product Datasheet: https://www.oras.com/datasheet/1022/en; Product Family: Oras Safira; Product URL: https://www.oras.com/en/products/oras-safira/product/1022/; Type Name: 1022 Kitchen faucet
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Aerator; Flow Rate At 300kPa: 0.00600349 m3/s; Hand Shower: Side brush; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Mounting Holes: 1 mounting hole; Pressure Loss With Flow 01ls: 100000 Pa; Spout Type: Swivel spout
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1022(2017); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1022; Name: 1022 Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:54x251x162 mm / Hand shower: 43x78x362 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1022; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1022 Kitchen faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.111159 m2; Volume: 0.00341293 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1022(2017): 1022 Kitchen faucet; Family and Type: 1022(2017): 1022 Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1022(2017): 1022 Kitchen faucet; Type Id: 1022(2017): 1022 Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
